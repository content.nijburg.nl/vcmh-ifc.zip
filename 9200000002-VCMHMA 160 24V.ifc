Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-05-05T16:35:18
Written by: ODA IFC SDK 22.8
Made in: 22.1.21.13 - Exporter 22.1.21.13 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_929519 | SOURCE
Port_929519 | SINK

# IfcFlowController: NLRS_57_DUA_UN_round-constant-volume-damper-vcmh_sacs:Double wall, NLRS_57_DUA_UN_round-constant-volume-damper-vcmh_sacs:Double wall:929519
In: Default
Type - Description: Round Volume Damper VCMH; PredefinedType: CONTROLDAMPER; Classification: 57.00 (Uniformat); Material: Belimo_Grey
Type - Constraints - Default Elevation: 0 mm
Type - General - Product_Data: VCMH_Data
Type - Identity Data - Assembly Code: 57.00; Description: Round Volume Damper VCMH; Manufacturer: Solid Air Climate Solutions; Model: Constant volume damper - Round; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 29-04-2022; NLRS_C_content_provider: Solid Air Climate Systems; NLRS_C_content_versie: Versie 3.19.00; NLRS_C_description: Round Volume Damper VCMH; NLRS_C_niveau ontwikkeling: LOD400; Type Comments: Check flow direction!; Type Name: Double wall; URL: https://solid-air.nl/producten/solid-air-volumeregelaar-vcmh-2/
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_round-constant-volume-damper-vcmh_sacs
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Type - Pset_ProductRequirements - Category: Duct Accessories
Material: Belimo_Grey, NLRS_A_SACS_SVZ
Pset_DistributionFlowElementCommon - Reference: Double wall; sets with these values: 2
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.000282722 m2; External_Diameter_Double_Wall: 250 mm; NLRS_C_lengte: 249 mm; NLRS_M_c01_diameter: 160 mm; SACS_Duct_Used_Size: 160 mm; Size: 160ø-160ø; Volume: 0.00904292 m3
Graphics - Use Annotation Scale: no
Identity Data - Mark: 98; NLRS_C_model: VCMHMA 160 24V; SACS_Article_Code: 9200000002; SACS_Gross_Cost: 589; SACS_Price_Date: 01-02-2022
Insulation - Insulation Thickness: 0 mm; Overall Size: 160 mmø-160 mmø
Lining - Free Size: 160 mmø-160 mmø; Lining Thickness: 0 mm
Mechanical - System Classification: Undefined
Mechanical - Flow - Advised mininmal air velocity: 4 m/s; Minimal required ▲P over damper: 50 Pa; NLRS_M_c01_debiet: 0 m3/s; NLRS_M_c01_drukverlies_statisch: 50 Pa; Pressure Drop: 0 Pa; SACS_Air_Velocity: 0 m/s
Model Properties - Control type (0-2): 1; SACS_Option_1: 24 volt, 2positions; SACS_Option_2: Double wall
Other - Family: NLRS_57_DUA_UN_round-constant-volume-damper-vcmh_sacs; Family and Type: NLRS_57_DUA_UN_round-constant-volume-damper-vcmh_sacs: Double wall; Type: Double wall; Type Id: 926026
Phasing - Phase Created: New Construction
Text - SACS_Warning_Text_Flow: Airflow below advised 4m/s
Visibility - SACS_Disable_Warning: yes; Show_recommended_placement_zone: yes
