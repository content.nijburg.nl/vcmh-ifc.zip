Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-05-05T16:35:23
Written by: ODA IFC SDK 22.8
Made in: 22.1.21.13 - Exporter 22.1.21.13 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_929530 | SOURCE
Port_929530 | SINK

# IfcFlowController: NLRS_57_DUA_UN_round-constant-volume-damper-vcmh_sacs:Single wall, NLRS_57_DUA_UN_round-constant-volume-damper-vcmh_sacs:Single wall:929530
In: Default
Type - Description: Round Volume Damper VCMH; PredefinedType: CONTROLDAMPER; Classification: 57.00 (Uniformat); Material: SACS_Label
Type - Constraints - Default Elevation: 0 mm
Type - General - Product_Data: VCMH_Data
Type - Identity Data - Assembly Code: 57.00; Description: Round Volume Damper VCMH; Manufacturer: Solid Air Climate Solutions; Model: Constant volume damper - Round; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 29-04-2022; NLRS_C_content_provider: Solid Air Climate Systems; NLRS_C_content_versie: Versie 3.19.00; NLRS_C_description: Round Volume Damper VCMH; NLRS_C_niveau ontwikkeling: LOD400; Type Comments: Check flow direction!; Type Name: Single wall; URL: https://solid-air.nl/producten/solid-air-volumeregelaar-vcmh/
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_round-constant-volume-damper-vcmh_sacs
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Type - Pset_ProductRequirements - Category: Duct Accessories
Material: NLRS_A_SACS_SVZ
Pset_DistributionFlowElementCommon - Reference: Single wall; sets with these values: 2
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.000282722 m2; External_Diameter_Double_Wall: 170 mm; NLRS_C_lengte: 249 mm; NLRS_M_c01_diameter: 80 mm; SACS_Duct_Used_Size: 80 mm; Size: 80ø-80ø; Volume: 0.00182018 m3
Graphics - Use Annotation Scale: no
Identity Data - Mark: 109; NLRS_C_model: VCMHOR 80; SACS_Article_Code: 9200000050; SACS_Gross_Cost: 169; SACS_Price_Date: 01-02-2022
Insulation - Insulation Thickness: 0 mm; Overall Size: 80 mmø-80 mmø
Lining - Free Size: 80 mmø-80 mmø; Lining Thickness: 0 mm
Mechanical - System Classification: Undefined
Mechanical - Flow - Advised mininmal air velocity: 4 m/s; Minimal required ▲P over damper: 50 Pa; NLRS_M_c01_debiet: 0 m3/s; NLRS_M_c01_drukverlies_statisch: 50 Pa; Pressure Drop: 0 Pa; SACS_Air_Velocity: 0 m/s
Model Properties - Control type (0-2): 0; SACS_Option_1: Manual; SACS_Option_2: Single wall
Other - Family: NLRS_57_DUA_UN_round-constant-volume-damper-vcmh_sacs; Family and Type: NLRS_57_DUA_UN_round-constant-volume-damper-vcmh_sacs: Single wall; Type: Single wall; Type Id: 926024
Phasing - Phase Created: New Construction
Text - SACS_Warning_Text_Flow: Airflow below advised 4m/s
Visibility - SACS_Disable_Warning: yes; Show_recommended_placement_zone: yes
